# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, USE_HAL_DRIVER, STM32F407xx
  c include: ..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\net\lwip\port;..\..\..\components\net\sal\impl;packages\Micro-XRCE-DDS-Client-latest\src\c\core\serialization;packages\Micro-XRCE-DDS-Client-latest\src\c\profile\transport\ip\udp;packages\Micro-XRCE-DDS-Client-latest\src\c\core\session\stream;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\libc\compilers\common\include;packages\Micro-XRCE-DDS-Client-latest\src\ucdr\src\c;..\..\..\libcpu\arm\cortex-m4;board\CubeMX_Config\Inc;packages\Micro-XRCE-DDS-Client-latest\src\ucdr\include;..\libraries\HAL_Drivers\CMSIS\Include;packages\Micro-XRCE-DDS-Client-latest\src\c\core\session;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\HAL_Drivers\config;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\io\poll;packages\Micro-XRCE-DDS-Client-latest\src\c\core\log;packages\Micro-XRCE-DDS-Client-latest\src\c\util;applications;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\net\sal\include\socket;packages\Micro-XRCE-DDS-Client-latest\src\c\profile\transport\serial;.;..\..\..\components\net\netdev\include;..\libraries\HAL_Drivers;packages\Micro-XRCE-DDS-Client-latest\inc;..\..\..\components\libc\posix\ipc;..\..\..\components\finsh;board;..\..\..\components\drivers\include;..\..\..\components\net\sal\include;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;board\ports;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;packages\Micro-XRCE-DDS-Client-latest\src\c\profile\transport\ip\tcp;..\..\..\components\dfs\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/phy/: phy.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: phy_reset.c
    ../libraries/HAL_Drivers/: drv_common.c drv_eth.c drv_gpio.c drv_soft_i2c.c drv_usart.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh.c msh_parse.c msh_file.c cmd.c shell.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_crc.c stm32f4xx_hal_eth.c stm32f4xx_hal_cec.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group Micro-XRCE-DDS-Client
    packages/Micro-XRCE-DDS-Client-latest/examples/: example_uros.c
    packages/Micro-XRCE-DDS-Client-latest/examples/msgs/: Header.c Time.c
    packages/Micro-XRCE-DDS-Client-latest/src/c/core/log/: log.c
    packages/Micro-XRCE-DDS-Client-latest/src/c/core/serialization/: xrce_header.c xrce_subheader.c xrce_types.c
    packages/Micro-XRCE-DDS-Client-latest/src/c/core/session/: common_create_entities.c create_entities_ref.c create_entities_xml.c object_id.c read_access.c session.c session_info.c submessage.c write_access.c
    packages/Micro-XRCE-DDS-Client-latest/src/c/core/session/stream/: input_best_effort_stream.c input_reliable_stream.c output_best_effort_stream.c output_reliable_stream.c seq_num.c stream_id.c stream_storage.c
    packages/Micro-XRCE-DDS-Client-latest/src/c/profile/transport/ip/tcp/: tcp_transport.c tcp_transport_external.c
    packages/Micro-XRCE-DDS-Client-latest/src/c/profile/transport/ip/udp/: udp_transport.c udp_transport_external.c
    packages/Micro-XRCE-DDS-Client-latest/src/c/profile/transport/serial/: serial_protocol.c serial_transport.c serial_transport_external.c
    packages/Micro-XRCE-DDS-Client-latest/src/c/util/: time.c
    packages/Micro-XRCE-DDS-Client-latest/src/ucdr/src/c/: common.c
    packages/Micro-XRCE-DDS-Client-latest/src/ucdr/src/c/types/: array.c basic.c sequence.c string.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
